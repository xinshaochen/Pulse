# Keil uVision project Project.uvproj, settings and files
target Project (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD
  c include: ..\Boot;..\Refer\inc;..\Refer\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Project
    ./: main.c
  group Boot
    ../Boot/: startup_stm32f10x_md.s
  group Refer
    ../Refer/src/: led.c delay.c sys.c motor.c pid.c sensor.c spi.c uart.c uartprotocol.c Timer.c iic.c mpu6050.c ADC.c RC522.c wifi.c encoder.c servo.c filter.c pulse.c Delta robot.c
    ../Refer/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
